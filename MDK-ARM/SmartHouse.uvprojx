# Keil uVision project SmartHouse.uvprojx, settings and files
target SmartHouse (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Smart house
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Inc;                                                           ../Drivers/STM32F3xx_HAL_Driver/Inc;                                                           ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;                                                           ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                                                           ../Drivers/CMSIS/Include;                                                           ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Application/User
    ../Src/: stm32f3xx_it.c main.c stm32f3xx_hal_msp.c LiquidCrystal.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_spi.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash.c stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c
software components: CMSIS:CORE 4.3.0
